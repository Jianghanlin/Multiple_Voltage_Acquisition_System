# Keil uVision project select_system.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: select_system +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./Sources/: main.c
  group Sources
    ./Sources/: AT89C52_init.h AT89C52_init.c delay.c delay.h lcd_init.c lcd_init.h lcd_display.c lcd_display.h ADC.c ADC.h adjust_voltage.c adjust_voltage.h key_check.c key_check.h led_warning.c led_warning.h my_info.c my_info.h
